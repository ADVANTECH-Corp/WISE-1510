<?xml version="1.0" encoding="utf-8"?>
<workspace>
	<project>
		<path>$WS_DIR$/loranode_WS1510_sdk.ewp</path>
	</project>
	<batchBuild></batchBuild>
</workspace>