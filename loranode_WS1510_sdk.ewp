# IAR project loranode_WS1510_sdk.ewp, settings and files
configuration loranode_WS1510_sdk (ARM, debug)
  General.OGChipSelectEditMenu: STM32L443RC ST STM32L443RC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDiagSuppress: Pa050,Pa084,Pa093,Pa082
  ICCARM.IExtraOptions: -DDEVICE_RTC=1; --enable_restrict; -DTOOLCHAIN_object; -DARM_MATH_CM4; --guard_calls; --preinclude=mbed_config.h; -DMBEDTLS_CONFIG_HW_SUPPORT; -DTARGET_MTB_ADV_WISE_1510; -DDEVICE_SLEEP=1; --diag_suppress=Pa050,Pa084,Pa093,Pa082; -DDEVICE_PORTINOUT=1; -e; -DDEVICE_PWMOUT=1; -DDEVICE_I2C_ASYNCH=1; -DTARGET_FF_ARDUINO; -DTARGET_RTOS_M4_M7; -DDEVICE_CAN=1; -DDEVICE_PORTOUT=1; -DDEVICE_FLASH=1; -DDEVICE_STDIO_MESSAGES=1; -DDEVICE_ANALOGOUT=1; -DTARGET_LIKE_MBED; -DDEVICE_SERIAL_FC=1; -DDEVICE_INTERRUPTIN=1; -DDEVICE_SERIAL=1; -DTARGET_STM32L443xC; -DTARGET_LIKE_CORTEX_M4; -r; -DTARGET_CORTEX_M; -DDEVICE_PORTIN=1; -DMBED_BUILD_TIMESTAMP=1523610942.62; -DDEVICE_I2C=1; -D__CORTEX_M4; -DTARGET_CORTEX; -DDEVICE_TRNG=1; -DTARGET_STM; -DDEVICE_ANALOGIN=1; -DTARGET_UVISOR_UNSUPPORTED; --no_wrap_diagnostics; -DHSE_VALUE=25000000; -DTARGET_FAMILY_STM32; -DTARGET_DEBUG; -DDEVICE_SPI=1; -D__MBED__=1; -DTOOLCHAIN_IAR; -DDEVICE_SPISLAVE=1; -DTARGET_STM32L4; -DMBED_TRAP_ERRORS_ENABLED=1; -DTARGET_M4; -DMBED_DEBUG; -DTARGET_STM32L443RC; -D__FPU_PRESENT=1; -DDEVICE_I2CSLAVE=1; -D__CMSIS_RTOS; -DDEVICE_SPI_ASYNCH=1; -DTRANSACTION_QUEUE_SIZE_SPI=2; -D__MBED_CMSIS_RTOS_CM; -DBUILD_SDK=; -DREGION_AS923_JP=
  ICCARM.CCIncludePath2: .; ./settings; ./TargetsJson; ./Bootloader; ./Release; ./Release/Internal_Record; ./Release/External_Release; ./mbed-os; ./mbed-os/drivers; ./mbed-os/targets; ./mbed-os/targets/TARGET_STM; ./mbed-os/targets/TARGET_STM/TARGET_STM32L4; ./mbed-os/targets/TARGET_STM/TARGET_STM32L4/TARGET_STM32L443xC; ./mbed-os/targets/TARGET_STM/TARGET_STM32L4/TARGET_STM32L443xC/TARGET_MTB_ADV_WISE_1510; ./mbed-os/targets/TARGET_STM/TARGET_STM32L4/TARGET_STM32L443xC/device; ./mbed-os/targets/TARGET_STM/TARGET_STM32L4/TARGET_STM32L443xC/device/TOOLCHAIN_IAR; ./mbed-os/targets/TARGET_STM/TARGET_STM32L4/device; ./mbed-os/events; ./mbed-os/events/equeue; ./mbed-os/platform; ./mbed-os/cmsis; ./mbed-os/cmsis/TARGET_CORTEX_M; ./mbed-os/cmsis/TARGET_CORTEX_M/TOOLCHAIN_IAR; ./mbed-os/hal; ./mbed-os/hal/storage_abstraction; ./mbed-os/rtos; ./mbed-os/rtos/TARGET_CORTEX; ./mbed-os/rtos/TARGET_CORTEX/TARGET_CORTEX_M; ./mbed-os/rtos/TARGET_CORTEX/TARGET_CORTEX_M/TOOLCHAIN_IAR; ./mbed-os/rtos/TARGET_CORTEX/rtx5; ./mbed-os/rtos/TARGET_CORTEX/rtx5/Source; ./mbed-os/rtos/TARGET_CORTEX/rtx5/Include; ./mbed-os/rtos/TARGET_CORTEX/rtx5/RTX; ./mbed-os/rtos/TARGET_CORTEX/rtx5/RTX/Source; ./mbed-os/rtos/TARGET_CORTEX/rtx5/RTX/Source/TOOLCHAIN_IAR; ./mbed-os/rtos/TARGET_CORTEX/rtx5/RTX/Source/TOOLCHAIN_IAR/TARGET_RTOS_M4_M7; ./mbed-os/rtos/TARGET_CORTEX/rtx5/RTX/Include; ./mbed-os/rtos/TARGET_CORTEX/rtx5/RTX/Config; ./mbed-os/rtos/TARGET_CORTEX/rtx4; ./USBDevice; ./USBDevice/USBSerial; ./USBDevice/USBHID; ./USBDevice/USBAudio; ./USBDevice/USBDevice; ./USBDevice/USBDevice/TARGET_STM; ./USBDevice/USBMIDI; ./USBDevice/USBMSD; ./lmic_generic; ./BufferedSerial; ./BufferedSerial/Buffer; 
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AExtraOptionsV2: -DTRANSACTION_QUEUE_SIZE_SPI=2; -D__CORTEX_M4; -DARM_MATH_CM4; -D__FPU_PRESENT=1; -DHSE_VALUE=25000000; -D__MBED_CMSIS_RTOS_CM; -D__CMSIS_RTOS; -DMBEDTLS_CONFIG_HW_SUPPORT
  OBJCOPY.OOCOutputFile: loranode_WS1510_sdk.bin
  ILINK.IlinkOutputFile: name.out
  ILINK.IlinkIcfFile: ./mbed-os/targets/TARGET_STM/TARGET_STM32L4/TARGET_STM32L443xC/device/TOOLCHAIN_IAR/stm32l443xx.icf
  ILINK.IlinkExtraOptions: --skip_dynamic_initialization; --threaded_lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group loranode_WS1510_sdk
    ./: libLoraNodeR1104v1iJP.a main.cpp mbed_config.h node_api.h
  group mbed-os
    mbed-os/drivers/: AnalogIn.cpp AnalogIn.h AnalogOut.h BusIn.cpp BusIn.h BusInOut.cpp BusInOut.h BusOut.cpp BusOut.h CAN.cpp CAN.h DigitalIn.h DigitalInOut.h DigitalOut.h Ethernet.cpp Ethernet.h FlashIAP.cpp FlashIAP.h I2C.cpp I2C.h I2CSlave.cpp I2CSlave.h InterruptIn.cpp InterruptIn.h InterruptManager.cpp InterruptManager.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h MbedCRC.cpp MbedCRC.h PortIn.h PortInOut.h PortOut.h PwmOut.h RawSerial.cpp RawSerial.h Serial.cpp Serial.h SerialBase.cpp SerialBase.h SerialWireOutput.h SPI.cpp SPI.h SPISlave.cpp SPISlave.h TableCRC.cpp TableCRC.h Ticker.cpp Ticker.h Timeout.cpp Timeout.h Timer.cpp Timer.h TimerEvent.cpp TimerEvent.h UARTSerial.cpp UARTSerial.h
    mbed-os/targets/TARGET_STM/: analogin_api.c analogout_api.c can_api.c gpio_api.c gpio_irq_api.c gpio_object.h hal_tick_16b.c hal_tick_32b.c i2c_api.c lp_ticker.c mbed_overrides.c mbed_rtx.h nvic_addr.h PeripheralPins.h pinmap.c PinNamesTypes.h port_api.c PortNames.h pwmout_api.c rtc_api.c rtc_api_hal.h serial_api.c serial_api_hal.h sleep.c stm32_assert.h stm_spi_api.c trng_api.c us_ticker_16b.c us_ticker_32b.c
    mbed-os/hal/: analogin_api.h analogout_api.h buffer.h can_api.h can_helper.h critical_section_api.h dma_api.h emac_api.h ethernet_api.h flash_api.h gpio_api.h gpio_irq_api.h i2c_api.h itm_api.h lp_ticker_api.h mbed_critical_section_api.c mbed_flash_api.c mbed_gpio.c mbed_itm_api.c mbed_lp_ticker_api.c mbed_pinmap_common.c mbed_sleep_manager.c mbed_ticker_api.c mbed_us_ticker_api.c pinmap.h port_api.h pwmout_api.h rtc_api.h serial_api.h sleep_api.h spi_api.h ticker_api.h trng_api.h us_ticker_api.h
    mbed-os/targets/TARGET_STM/TARGET_STM32L4/: analogin_device.c analogout_device.c can_device.h common_objects.h device.h flash_api.c gpio_irq_device.c gpio_irq_device.h i2c_device.h l4_retarget.c pin_device.h pwmout_device.c pwmout_device.h serial_device.c spi_api.c spi_device.h
    mbed-os/cmsis/TARGET_CORTEX_M/: arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm23.h core_cm3.h core_cm33.h core_cm4.h core_cm7.h core_cmSecureAccess.h core_sc000.h core_sc300.h mpu_armv7.h mpu_armv8.h tz_context.h
    mbed-os/platform/: ATCmdParser.cpp ATCmdParser.h Callback.h CallChain.cpp CallChain.h CircularBuffer.h critical.h CriticalSectionLock.h CThunk.h DeepSleepLock.h DirHandle.h FileBase.cpp FileBase.h FileHandle.cpp FileHandle.h FileLike.h FilePath.cpp FilePath.h FileSystemHandle.cpp FileSystemHandle.h FileSystemLike.h FunctionPointer.h LocalFileSystem.cpp LocalFileSystem.h mbed_alloc_wrappers.cpp mbed_application.c mbed_application.h mbed_assert.c mbed_assert.h mbed_board.c mbed_critical.c mbed_critical.h mbed_debug.h mbed_error.c mbed_error.h mbed_interface.c mbed_interface.h mbed_mem_trace.cpp mbed_mem_trace.h mbed_mktime.c mbed_mktime.h mbed_poll.cpp mbed_poll.h mbed_power_mgmt.h mbed_preprocessor.h mbed_retarget.cpp mbed_retarget.h mbed_rtc_time.cpp mbed_rtc_time.h mbed_sdk_boot.c mbed_semihost_api.c mbed_semihost_api.h mbed_sleep.h mbed_stats.c mbed_stats.h mbed_toolchain.h mbed_wait_api.h mbed_wait_api_no_rtos.c mbed_wait_api_rtos.cpp NonCopyable.h platform.h PlatformMutex.h rtc_time.h ScopedLock.h semihost_api.h SingletonPtr.h sleep.h Stream.cpp Stream.h toolchain.h Transaction.h wait_api.h
    mbed-os/cmsis/TARGET_CORTEX_M/TOOLCHAIN_IAR/: cmain.S
    mbed-os/targets/TARGET_STM/TARGET_STM32L4/TARGET_STM32L443xC/device/: cmsis.h cmsis_nvic.h hal_tick.h stm32l443xx.h stm32l4xx.h system_stm32l4xx.h
    mbed-os/rtos/TARGET_CORTEX/rtx4/: cmsis_os.h cmsis_os1.c
    mbed-os/rtos/TARGET_CORTEX/rtx5/Include/: cmsis_os2.h os_tick.h
    mbed-os/rtos/: ConditionVariable.cpp ConditionVariable.h EventFlags.cpp EventFlags.h Kernel.cpp Kernel.h Mail.h MemoryPool.h Mutex.cpp Mutex.h Queue.h rtos.h rtos_idle.h RtosTimer.cpp RtosTimer.h Semaphore.cpp Semaphore.h Thread.cpp Thread.h
    mbed-os/hal/storage_abstraction/: Driver_Common.h Driver_Storage.h
    mbed-os/events/equeue/: equeue.c equeue.h equeue_mbed.cpp equeue_platform.h equeue_posix.c
    mbed-os/events/: Event.h EventQueue.cpp EventQueue.h mbed_events.h mbed_shared_queues.cpp mbed_shared_queues.h
    mbed-os/rtos/TARGET_CORTEX/TARGET_CORTEX_M/TOOLCHAIN_IAR/: except.S
    mbed-os/rtos/TARGET_CORTEX/rtx5/RTX/Source/TOOLCHAIN_IAR/TARGET_RTOS_M4_M7/: irq_cm4f.S
    mbed-os/: mbed.h
    mbed-os/rtos/TARGET_CORTEX/: mbed_boot.c mbed_rtos1_types.h mbed_rtos_storage.h mbed_rtx_conf.h mbed_rtx_handlers.c mbed_rtx_idle.cpp SysTimer.cpp SysTimer.h
    mbed-os/rtos/TARGET_CORTEX/TARGET_CORTEX_M/: mbed_rtx_fault_handler.c mbed_rtx_fault_handler.h
    mbed-os/targets/TARGET_STM/TARGET_STM32L4/TARGET_STM32L443xC/: objects.h
    mbed-os/rtos/TARGET_CORTEX/rtx5/Source/: os_systick.c os_tick_ptim.c
    mbed-os/targets/TARGET_STM/TARGET_STM32L4/TARGET_STM32L443xC/TARGET_MTB_ADV_WISE_1510/: PeripheralNames.h PeripheralPins.c PinNames.h system_clock.c
    mbed-os/rtos/TARGET_CORTEX/rtx5/RTX/Source/: rt_OsEventObserver.c rt_OsEventObserver.h rtx_core_c.h rtx_core_ca.h rtx_core_cm.h rtx_delay.c rtx_evflags.c rtx_evr.c rtx_kernel.c rtx_lib.c rtx_lib.h rtx_memory.c rtx_mempool.c rtx_msgqueue.c rtx_mutex.c rtx_semaphore.c rtx_system.c rtx_thread.c rtx_timer.c
    mbed-os/rtos/TARGET_CORTEX/rtx5/RTX/Config/: RTX_Config.c RTX_Config.h
    mbed-os/rtos/TARGET_CORTEX/rtx5/RTX/Include/: rtx_evr.h rtx_os.h
    mbed-os/targets/TARGET_STM/TARGET_STM32L4/TARGET_STM32L443xC/device/TOOLCHAIN_IAR/: startup_stm32l443xx.S
    mbed-os/targets/TARGET_STM/TARGET_STM32L4/device/: stm32_hal_legacy.h stm32l4xx_hal.c stm32l4xx_hal.h stm32l4xx_hal_adc.c stm32l4xx_hal_adc.h stm32l4xx_hal_adc_ex.c stm32l4xx_hal_adc_ex.h stm32l4xx_hal_can.c stm32l4xx_hal_can.h stm32l4xx_hal_can_legacy.c stm32l4xx_hal_can_legacy.h stm32l4xx_hal_comp.c stm32l4xx_hal_comp.h stm32l4xx_hal_conf.h stm32l4xx_hal_cortex.c stm32l4xx_hal_cortex.h stm32l4xx_hal_crc.c stm32l4xx_hal_crc.h stm32l4xx_hal_crc_ex.c stm32l4xx_hal_crc_ex.h stm32l4xx_hal_cryp.c stm32l4xx_hal_cryp.h stm32l4xx_hal_cryp_ex.c stm32l4xx_hal_cryp_ex.h stm32l4xx_hal_dac.c stm32l4xx_hal_dac.h stm32l4xx_hal_dac_ex.c stm32l4xx_hal_dac_ex.h stm32l4xx_hal_dcmi.c stm32l4xx_hal_dcmi.h stm32l4xx_hal_def.h stm32l4xx_hal_dfsdm.c stm32l4xx_hal_dfsdm.h stm32l4xx_hal_dfsdm_ex.c stm32l4xx_hal_dfsdm_ex.h stm32l4xx_hal_dma.c stm32l4xx_hal_dma.h stm32l4xx_hal_dma2d.c stm32l4xx_hal_dma2d.h stm32l4xx_hal_dma_ex.c stm32l4xx_hal_dma_ex.h stm32l4xx_hal_dsi.c stm32l4xx_hal_dsi.h stm32l4xx_hal_firewall.c stm32l4xx_hal_firewall.h stm32l4xx_hal_flash.c stm32l4xx_hal_flash.h stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ex.h stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_flash_ramfunc.h stm32l4xx_hal_gfxmmu.c stm32l4xx_hal_gfxmmu.h stm32l4xx_hal_gpio.c stm32l4xx_hal_gpio.h stm32l4xx_hal_gpio_ex.h stm32l4xx_hal_hash.c stm32l4xx_hal_hash.h stm32l4xx_hal_hash_ex.c stm32l4xx_hal_hash_ex.h stm32l4xx_hal_hcd.c stm32l4xx_hal_hcd.h stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c.h stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_i2c_ex.h stm32l4xx_hal_irda.c stm32l4xx_hal_irda.h stm32l4xx_hal_irda_ex.h stm32l4xx_hal_iwdg.c stm32l4xx_hal_iwdg.h stm32l4xx_hal_lcd.c stm32l4xx_hal_lcd.h stm32l4xx_hal_lptim.c stm32l4xx_hal_lptim.h stm32l4xx_hal_ltdc.c stm32l4xx_hal_ltdc.h stm32l4xx_hal_ltdc_ex.c stm32l4xx_hal_ltdc_ex.h stm32l4xx_hal_nand.c stm32l4xx_hal_nand.h stm32l4xx_hal_nor.c stm32l4xx_hal_nor.h stm32l4xx_hal_opamp.c stm32l4xx_hal_opamp.h stm32l4xx_hal_opamp_ex.c stm32l4xx_hal_opamp_ex.h stm32l4xx_hal_ospi.c stm32l4xx_hal_ospi.h stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd.h stm32l4xx_hal_pcd_ex.c stm32l4xx_hal_pcd_ex.h stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr.h stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_pwr_ex.h stm32l4xx_hal_qspi.c stm32l4xx_hal_qspi.h stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc.h stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rcc_ex.h stm32l4xx_hal_rng.c stm32l4xx_hal_rng.h stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc.h stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_rtc_ex.h stm32l4xx_hal_sai.c stm32l4xx_hal_sai.h stm32l4xx_hal_sai_ex.c stm32l4xx_hal_sai_ex.h stm32l4xx_hal_sd.c stm32l4xx_hal_sd.h stm32l4xx_hal_sd_ex.c stm32l4xx_hal_sd_ex.h stm32l4xx_hal_smartcard.c stm32l4xx_hal_smartcard.h stm32l4xx_hal_smartcard_ex.c stm32l4xx_hal_smartcard_ex.h stm32l4xx_hal_smbus.c stm32l4xx_hal_smbus.h stm32l4xx_hal_spi.c stm32l4xx_hal_spi.h stm32l4xx_hal_spi_ex.c stm32l4xx_hal_spi_ex.h stm32l4xx_hal_sram.c stm32l4xx_hal_sram.h stm32l4xx_hal_swpmi.c stm32l4xx_hal_swpmi.h stm32l4xx_hal_tim.c stm32l4xx_hal_tim.h stm32l4xx_hal_tim_ex.c stm32l4xx_hal_tim_ex.h stm32l4xx_hal_tsc.c stm32l4xx_hal_tsc.h stm32l4xx_hal_uart.c stm32l4xx_hal_uart.h stm32l4xx_hal_uart_ex.c stm32l4xx_hal_uart_ex.h stm32l4xx_hal_usart.c stm32l4xx_hal_usart.h stm32l4xx_hal_usart_ex.c stm32l4xx_hal_usart_ex.h stm32l4xx_hal_wwdg.c stm32l4xx_hal_wwdg.h stm32l4xx_ll_adc.c stm32l4xx_ll_adc.h stm32l4xx_ll_bus.h stm32l4xx_ll_comp.c stm32l4xx_ll_comp.h stm32l4xx_ll_cortex.h stm32l4xx_ll_crc.c stm32l4xx_ll_crc.h stm32l4xx_ll_crs.c stm32l4xx_ll_crs.h stm32l4xx_ll_dac.c stm32l4xx_ll_dac.h stm32l4xx_ll_dma.c stm32l4xx_ll_dma.h stm32l4xx_ll_dma2d.c stm32l4xx_ll_dma2d.h stm32l4xx_ll_dmamux.h stm32l4xx_ll_exti.c stm32l4xx_ll_exti.h stm32l4xx_ll_fmc.c stm32l4xx_ll_fmc.h stm32l4xx_ll_gpio.c stm32l4xx_ll_gpio.h stm32l4xx_ll_i2c.c stm32l4xx_ll_i2c.h stm32l4xx_ll_iwdg.h stm32l4xx_ll_lptim.c stm32l4xx_ll_lptim.h stm32l4xx_ll_lpuart.c stm32l4xx_ll_lpuart.h stm32l4xx_ll_opamp.c stm32l4xx_ll_opamp.h stm32l4xx_ll_pwr.c stm32l4xx_ll_pwr.h stm32l4xx_ll_rcc.c stm32l4xx_ll_rcc.h stm32l4xx_ll_rng.c stm32l4xx_ll_rng.h stm32l4xx_ll_rtc.c stm32l4xx_ll_rtc.h stm32l4xx_ll_sdmmc.c stm32l4xx_ll_sdmmc.h stm32l4xx_ll_spi.c stm32l4xx_ll_spi.h stm32l4xx_ll_swpmi.c stm32l4xx_ll_swpmi.h stm32l4xx_ll_system.h stm32l4xx_ll_tim.c stm32l4xx_ll_tim.h stm32l4xx_ll_usart.c stm32l4xx_ll_usart.h stm32l4xx_ll_usb.c stm32l4xx_ll_usb.h stm32l4xx_ll_utils.c stm32l4xx_ll_utils.h stm32l4xx_ll_wwdg.h system_stm32l4xx.c
